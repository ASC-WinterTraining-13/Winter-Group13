# Keil uVision project mm32f327x_g8p.uvprojx, settings and files
target mm32f327x_g8p_project (6240000::V6.24::ARMCLANG)
  device: MM32F3273G8P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32F327X_G8P
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\user\inc;..\code;..\..\libraries\zf_common;..\..\libraries\zf_device;..\..\libraries\zf_driver;..\..\libraries\sdk;..\..\libraries\sdk\CMSIS\Include;..\..\libraries\sdk\drivers;..\..\libraries\components\fatfs\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\libraries\sdk\mdk\linker\mm32f3277g_flash.scf
  group user_c
    ../USER/src/: main.c
    ../user/src/: isr.c
  group user_h
    ../user/inc/: isr.h
  group code
    ../code/: Menu.c Menu.h Mode_1.c Mode_1.h Mode_2.c Mode_2.h Mode_3.c Mode_3.h Mode_4.c Mode_4.h Mode_5.c Mode_5.h Core_Param.c Core_Param.h Debug_Page.c Debug_Page.h SandBox_Page.c SandBox_Page.h PID.c PID.h mpu6050_Analysis.c mpu6050_Analysis.h navigation.c navigation.h navi_flash.c navi_flash.h bluetooth_ch04_example.c bluetooth_ch04_example.h BuzzerAndLED.c BuzzerAndLED.h Encoder.c Encoder.h motor.c motor.h OLED.c OLED.h OLED_Data.c OLED_Data.h param_config.c param_config.h param_storage.c param_storage.h Track_Sensor.c Track_Sensor.h zf_device_bluetooth_ch04.c zf_device_bluetooth_ch04.h AI_tuning.c AI_tuning.h
  group doc
    ../../libraries/doc/: version.txt
  group zf_common
    ../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_interrupt.c zf_common_interrupt.h zf_common_headfile.h zf_common_typedef.h
  group zf_driver
    ../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_dac.c zf_driver_dac.h zf_driver_delay.c zf_driver_delay.h zf_driver_dma.c zf_driver_dma.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_iic.c zf_driver_iic.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_sdio.c zf_driver_sdio.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h
  group zf_device
    ../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h zf_device_camera.c zf_device_camera.h zf_device_config.h zf_device_config.lib zf_device_dl1a.c zf_device_dl1a.h zf_device_dm1xa.c zf_device_dm1xa.h zf_device_gps_tau1201.c zf_device_gps_tau1201.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_key.c zf_device_key.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_oled.c zf_device_oled.h zf_device_ov7725.c zf_device_ov7725.h zf_device_scc8660.c zf_device_scc8660.h zf_device_sdcard.c zf_device_sdcard.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_virtual_oscilloscope.c zf_device_virtual_oscilloscope.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h
  group sdk
    ../../libraries/sdk/: hal_device_registers.h mm32f3277g.h mm32f3277g_features.h system_mm32f3277g.c system_mm32f3277g.h
    ../../libraries/sdk/mdk/: startup_mm32f3277g.s
    ../../libraries/sdk/drivers/: hal_adc.c hal_adc.h hal_common.h hal_comp.c hal_comp.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_iwdg.c hal_iwdg.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_sdio.c hal_sdio.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim_16b.c hal_tim_16b.h hal_tim_32b.c hal_tim_32b.h hal_tim_adv.c hal_tim_adv.h hal_tim_basic.c hal_tim_basic.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group components_fatfs
    ../../libraries/components/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
